# Keil uVision project 工程文件.uvprojx, settings and files
target 工程 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\HARDWARE\Application;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\BEEP;..\HARDWARE\DEBUG;..\HARDWARE\DHT11;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\MQ2;..\HARDWARE\MQTT;..\HARDWARE\WIFI;..\HARDWARE\RELAY;..\HARDWARE\OLED;..\HARDWARE\GPS;..\HARDWARE\MQ135;..\HARDWARE\INFRARED;..\HARDWARE\JQ8900;..\HARDWARE\MQ2;..\HARDWARE\LSENS;..\HARDWARE\JW01;..\HARDWARE\FIRE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/ADC/: adc.c adc.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/DHT11/: dht11.c dht11.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/MQTT/: mqtt.c mqtt.h
    ../HARDWARE/WIFI/: wifi.c wifi.h
    ../HARDWARE/DEBUG/: al_debug.c al_debug.h
    ../HARDWARE/RELAY/: Relay.c Relay.h
    ../HARDWARE/INFRARED/: infrared.c infrared.h
    ../HARDWARE/MQ2/: mq.c mq.h
    ../HARDWARE/JW01/: jw01.c jw01.h
    ../HARDWARE/OLED/: oled.c oled.h oledfont.h
  group CORE
    ../HMAC/scr/: sys.c
    ../CORE/: core_cm3.c stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_adc.c
  group HMAC
    ../HMAC/scr/: utils_hmac.c utils_md5.c utils_sha1.c timer1.c timer2.c timer3.c timer4.c usart1.c usart2.c usart3.c delay.c
